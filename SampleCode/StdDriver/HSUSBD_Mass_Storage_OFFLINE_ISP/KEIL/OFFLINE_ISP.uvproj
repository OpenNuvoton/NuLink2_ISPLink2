# Keil uVision project OFFLINE_ISP.uvproj, settings and files
target HSUSBD_Mass_Storage_DataFlash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBD_Mass_Storage_DataFlash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\;..\ff8\src;..\HAL_Driver;..\ISP_HID_20;..\..\..\..\Library\UsbHostLib\inc;..\ISP_OFFLINE;..\STORAGE;..\LUA
  asm define: Stack_Size=0xb000 Heap_Size=0xb000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c Voltage.lib lua_isp.c
    ./obj/: OFFLINE_LIB.lib
    ../ISP_OFFLINE/: ISP_USBH_HID.c ISP_CMD.c ISP_DRIVER.C
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c
